# Keil uVision project Bootloader.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Bootloader
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./Core/Inc/: bootloader.h
    ./Core/Src/: bootloader.c main.c
    ./RTE/Device/STM32F405RGTx/: STM32F405_415_407_417_427_437_429_439.dbgconf STM32F405_415_407_417_427_437_429_439.dbgconf.base@1.0.1
    ./DebugConfig/: Target_1_STM32F405RGTx_1.0.1.dbgconf
    ./: Bootloader.uvoptx Bootloader.uvprojx README.md
